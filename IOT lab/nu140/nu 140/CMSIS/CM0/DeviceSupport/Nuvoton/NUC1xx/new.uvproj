# Keil uVision project new.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: new
  c flags: Optim=1
  c include: ..\..\..\CoreSupport;..\..\..\DeviceSupport;..\..\..\..\..\NuvotonPlatform_Keil\Include;..\..\..\..\..\NuvotonPlatform_Keil\Include\Driver;..\..\..\..\..\NuvotonPlatform_Keil\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_NUC1xx.s system_NUC1xx.c proj.c
    ../../../CoreSupport/: core_cm0.c
    ../../../../../NuvotonPlatform_Keil/Src/Driver/: DrvADC.c DrvSYS.c DrvUART.c DrvGPIO.c
    ../../../../../NuvotonPlatform_Keil/Src/NUC1xx-LB_002/: Ascii_Table.C ScanKey.c LCD_Driver.c
